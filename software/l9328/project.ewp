# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: D:/rtthread/RTT/libcpu/arm/common; libraries\STM32F10x_StdPeriph_Driver\inc; drivers; .; applications; D:/rtthread/RTT/components/init; D:/rtthread/RTT/libcpu/arm/cortex-m3; D:/rtthread/RTT/components/CMSIS/Include; D:/rtthread/RTT/components/finsh; D:/rtthread/RTT/components/drivers/include; D:/rtthread/RTT/include; libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCOptLevel: 3
  group applications
    applications/: application.c startup.c
  group drivers
    drivers/: board.c led.c dspin.c usart.c serial.c stm32f10x_it.c drv_rtc.c
  group STM32_StdPeriph
    libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group Kernel
    D:/rtthread/RTT/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    D:/rtthread/RTT/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
    D:/rtthread/RTT/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    D:/rtthread/RTT/components/drivers/rtc/: rtc.c
  group finsh
    D:/rtthread/RTT/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Components
    D:/rtthread/RTT/components/init/: components_init.c
